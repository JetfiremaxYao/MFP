Commit message: 0709 camera above cube and IK correct

File: genesis/assets/xml/ED6-URDF-0102.SLDASM/urdf/ED6-URDF-0102.SLDASM.urdf (robot description, URDF)
Before this commit: robot ED6-URDF-0102.SLDASM, 7 links, 6 joints
Joints:
- joint J1: axis 0 -1 0 -> 0 0 1
